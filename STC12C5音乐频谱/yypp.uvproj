# Keil uVision project yypp.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: yypp +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group
    ./src/: STARTUP.A51 yypp.c
